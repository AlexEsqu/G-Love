File: SK9822x15_O.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Premier jet PCB, A optimiser
Other:
- removed sheet SK9822x5_1
- added sheet SK9822xO (SK9822_O.kicad_sch)
